ARMNEON:class-native = "--enable-hardware-optimizations=on"
