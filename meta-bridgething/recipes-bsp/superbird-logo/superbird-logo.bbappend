# brand override for the BSP boot splash
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SUPERBIRD_BOOT_LOGO_NAME = "bridgething-bootup.bmp"
