SUMMARY = "Bridgething OTA artifact (.swu) - delta against bridgething-dev-image"

require ${THISDIR}/bridgething-update-delta.inc

BRIDGETHING_OTA_SOURCE_IMAGE = "bridgething-dev-image"
